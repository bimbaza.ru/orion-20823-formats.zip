Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:17:31+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-VXUNB-B-97
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Изделие бетонное благоустройства, ZSK-VXUNB-B-97 Вазон «Аллея» на бетонном основании · база — серый бетон
In: Площадка
Description: Изделие бетонное благоустройства. Вазон «Аллея» на бетонном основании · база — серый бетон; Classification: 05.3.02.03 Вазон уличный (Классификатор строительных ресурсов (КСР)); Material: Бетон
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-VXUNB-B-97; ModelReference: Вазон «Аллея» на бетонном основании · база — серый бетон; ProductionYear: 2026; ArticleNumber: ZSK-VXUNB-B-97
ORION_Изделие - Артикул: ZSK-VXUNB-B-97; Артикул прежний: SD-VXUNB-B-97; Наименование: Вазон «Аллея» на бетонном основании · база — серый бетон; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 400×400×700 мм; Материал: Бетон; Цена: 34 000 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/concrete/20823; Код КСИ: CPr>EDG010; Класс КСИ: Вазон уличный; Коды КСР: 05.3.02.03 … 59.1.15.02-0449
ADSK - ADSK_Наименование: Вазон «Аллея» на бетонном основании · база — серый бетон; ADSK_Марка: ZSK-VXUNB-B-97; ADSK_Код изделия: 05.3.02.03; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: Бетон; ADSK_URL страницы изделия: https://зск.рф/catalog/concrete/20823
ZSK_Благоустройство - ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDG010; ZSK_Артикул_прежний: SD-VXUNB-B-97
Qto_ORION - Длина: 400 mm; Ширина: 400 mm; Высота: 700 mm
